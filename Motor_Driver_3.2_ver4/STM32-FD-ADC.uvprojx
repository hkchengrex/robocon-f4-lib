# Keil uVision project STM32-FD-ADC.uvprojx, settings and files
target STM32-FD-ADC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-ADC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./startup/: startup_stm32f10x_md.s
  group Source Code
    ./user/: main.c system.c stm32f10x_it.c ticks.c uart.c approx_math.c can.c can_motor.c can_protocol.c velocity.c led.c encoder.c motor.c debug.c
  group libary
    ./FWlib/SRC/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_exti.c
    ./CM3/: core_cm3.c system_stm32f10x.c
